# Keil uVision project Project.uvprojx, settings and files
target Internal Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: CORE_M4  Gray
  c include: ..\inc;..\uC-CPU;..\uC-CPU\ARM-Cortex-M3\MDK-ARM;..\uCOS-II\Ports\ARM-Cortex-M3\Generic\MDK-ARM;..\uCOS-II\Source;..\Library\Drivers\include;..\Library\Core\Device\NXP\LPC43xx\Source\Templates;..\Library\Core\Device\NXP\LPC43xx\Include;..\Library\SYST;..\Library\Boards\Include;..\Hardware\hard_h;..\Application;..\GUI\GUI_H;..\GUI\GUI_H\Include;..\emWin\Config;..\emWin\header;..\Source\States\states_h
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC43xx.s
  group emWin_Lib
    ../emWin/library/: emWin_M3.lib
  group CMSIS
    ../Library/Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../Library/Drivers/source/: lpc43xx_uart.c lpc43xx_timer.c lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_lcd.c lpc43xx_adc.c lpc43xx_gpdma.c lpc43xx_mcpwm.c
  group uC-CPU
    ../uC-CPU/ARM-Cortex-M3/MDK-ARM/: cpu_c.c cpu.h cpu_a.asm
    ../uC-CPU/: cpu_def.h
  group uC-OS-II/Port
    ../uCOS-II/Ports/ARM-Cortex-M3/Generic/MDK-ARM/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group emWin_config
    ../emWin/Config/: GUI_X.c GUIConf.c LCDConf.c SIMConf.c
  group GUI
    ../GUI/GUI_C/: CodeConvert.c DataInterface.c FramewinDLG.c WIN.c WIN_Context.c WIN_Tree.c WinWindow.c GUIDEMO_Start.c WinMessage.c winSKIN.c
  group main
    ../src/: main.c bsp.c
    ../GUI/GUI_C/: WindowMain.c
    ../Hardware/hard_c/: GUI_main.c datafigures.c
    ../: Retarget.c
  group Hardware
    ../Hardware/hard_c/: ADC.c LED.c DAC.c Handler.c SPI.c FLASH.c LCD.c USART_Conf.c MLX90363.c Encoder.c Extern.c dataCRC.c timer.c torque.c test_UART0.c hand.c temperature.c EEPROM.c TIME.c 0420.c
  group states
    ../Source/States/states_c/: Error0x.c Error1x.c Error2x.c Error3x.c Error4x.c Error5x.c Error6x.c states.c
  group Readme
    ../: readme.txt record.txt
  group USB
    ../usb/source/: cdcuser.c serial.c USB_main.c usbcore.c usbdesc.c usbhw.c usbuser.c MODBUS.c
  group DEBUG-COM
    ../DEBUG-COM/source/: COM_TORQUE.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target Actor13 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.9.0
  cpu: as above
  output: Project +hex
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: CORE_M4 Gray  EE13 Encnew  UITEST_2
  c misc: --locale=english --no-multibyte-chars
  c include: ..\inc;..\uC-CPU;..\uC-CPU\ARM-Cortex-M3\MDK-ARM;..\uCOS-II\Ports\ARM-Cortex-M3\Generic\MDK-ARM;..\uCOS-II\Source;..\Library\Drivers\include;..\Library\Core\Device\NXP\LPC43xx\Source\Templates;..\Library\Core\Device\NXP\LPC43xx\Include;..\Library\SYST;..\Library\Boards\Include;..\Hardware\hard_h;..\GUI\GUI_H;..\GUI\GUI_H\Include;..\emWin\Config;..\emWin\header;..\Source\States\states_h;..\usb\include;..\DEBUG-COM\include;..\fat;..\RTT
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x10080000 size 0xa000
  scatter file: .\Project.sct
software components: CMSIS:CORE 5.1.1
